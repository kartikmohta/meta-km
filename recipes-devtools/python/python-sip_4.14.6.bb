require python-sip.inc
PR = "ml0"

SRC_URI[md5sum] = "d6493b9f0a7911566545f694327314c4"
SRC_URI[sha256sum] = "4adda378be3ed0c2bb15f502b8437be72ddada20201b9433ea0df50c7b698daf"
