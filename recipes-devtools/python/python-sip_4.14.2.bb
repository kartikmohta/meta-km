require python-sip.inc
PR = "ml0"

SRC_URI[md5sum] = "b93442e745b3be2fad89de0686a76ce9"
SRC_URI[sha256sum] = "1a9d3bf26c821f369c175f8e68946b79bc994da4f96e8f5ecff06e6ee7ac0528"
