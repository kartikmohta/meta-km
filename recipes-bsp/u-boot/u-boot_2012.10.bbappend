FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += " \
           file://u-boot-route-uart2-to-header.patch \
          "
